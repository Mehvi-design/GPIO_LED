# Keil uVision project LED_Driver.uvprojx, settings and files
target LED_Driver (ARM-ADS)
  device: STM32F334R8Tx STMicroelectronics
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LED_Driver +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F334x8
  c include: ../../Core/Inc;../../Drivers/STM32F3xx_HAL_Driver/Inc;../../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../../Drivers/CMSIS/Include;../../Middlewares/ST/ARM/DSP/Inc
  scatter file: stm32f334xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Application/User/Core
    ../../Core/Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_exti.c stm32f3xx_ll_adc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_dma.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_ll_rcc.c stm32f3xx_ll_hrtim.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_ll_usart.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32f3xx.c
  group Middlewares/Library/DSP Library/DSP Library
    ./: 
    ../../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
software components: CMSIS:CORE 4.3.0
